Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Tresse - Cube - ifc4.ifc
Time: 2023-10-09T15:17:29
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (5)
Name
 | 1_2 - ObjectType: SketchupGroup
 | 1_0 - ObjectType: SketchupGroup
 | 1_1 - ObjectType: SketchupGroup
 | 1_4 - ObjectType: SketchupGroup
 | 1_3 - ObjectType: SketchupGroup
